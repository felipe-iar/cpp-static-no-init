# IAR project demo.ewp, settings and files
configuration CPP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: memb0st.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration C (ARM, debug)
  as the first configuration, except:
  ICCARM.IccLang: 0
  group (top)
    ./: main.c main.cpp
